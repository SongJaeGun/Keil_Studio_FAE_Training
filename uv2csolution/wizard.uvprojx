# Keil uVision project wizard.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F756ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: firmware
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=4
  c define: MG_HAL_DISABLE_SYSTEM_INIT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c hal.h hal.c
  group Mongoose
    ./mongoose/: mongoose_impl.c mongoose_glue.h mongoose_fs.c mongoose_glue.c mongoose.c mongoose.h mongoose_config.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.2.5
